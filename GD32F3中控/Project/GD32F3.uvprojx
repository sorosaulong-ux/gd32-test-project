# Keil uVision project GD32F3.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F3
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER, GD32F30X_HD
  c include: ..\CMSIS;..\Firmware;..\Hardware;..\User;..\Firmware\Include;..\Firmware\Source;..\NET;..\Hardware\inc;..\Hardware\src;..\NET\device\inc;..\NET\device\src;..\NET\onenet\inc;..\NET\onenet\src;..\NET\MQTT;..\NET\CJSON
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/GD/GD32F30x/Include/: gd32f30x.h system_gd32f30x.h
    ../CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Hardware
    ../Hardware/inc/: delay.h key.h usart.h buzzer.h oled.h OLED_Font.h can_drive.h
    ../Hardware/src/: delay.c key.c usart.c buzzer.c oled.c can_drive.c
  group User
    ../User/: gd32f30x_it.c gd32f30x_it.h gd32f30x_libopt.h systick.h systick.c main.c
  group Firmware
    ../Firmware/Include/: gd32f30x_adc.h gd32f30x_bkp.h gd32f30x_can.h gd32f30x_crc.h gd32f30x_ctc.h gd32f30x_dac.h gd32f30x_dbg.h gd32f30x_dma.h gd32f30x_enet.h gd32f30x_exmc.h gd32f30x_exti.h gd32f30x_fmc.h gd32f30x_fwdgt.h gd32f30x_gpio.h gd32f30x_i2c.h gd32f30x_misc.h gd32f30x_pmu.h gd32f30x_rcu.h gd32f30x_rtc.h gd32f30x_sdio.h gd32f30x_spi.h gd32f30x_timer.h gd32f30x_usart.h gd32f30x_wwdgt.h
    ../Firmware/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group CJSON
    ../NET/CJSON/: cJSON.c cJSON.h
  group device
    ../NET/device/src/: esp8266.c
    ../NET/device/inc/: esp8266.h
  group MQTT
    ../NET/MQTT/: Common.h MqttKit.c MqttKit.h
  group onenet
    ../NET/onenet/inc/: base64.h hmac_sha1.h onenet.h
    ../NET/onenet/src/: base64.c hmac_sha1.c onenet.c
software components: CMSIS:CORE 5.6.0
