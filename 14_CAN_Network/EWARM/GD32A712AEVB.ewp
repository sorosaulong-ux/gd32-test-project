# IAR project GD32A712AEVB.ewp, settings and files
configuration GD32A712 (ARM, debug)
  General.OGChipSelectEditMenu: GD32A712AI GD GD32A712AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32A711X_A712X
  ICCARM.CCIncludePath2: ..\..\..\..\GD32A7xx_Firmware_Library\CMSIS\GD\GD32A7xx\Include; ..\..\..\..\GD32A7xx_Firmware_Library\GD32A7xx_standard_peripheral\Include; ..\..\..\Utilities; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GD32A712AEVB.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32a7xx_it.c main.c systick.c
  group CMSIS
    ../../../../GD32A7xx_Firmware_Library/CMSIS/GD/GD32A7xx/Source/: gd32a7xx_err_report.c system_gd32a71xx_a74xx.c
  group Doc
    ../: readme.txt
  group GD32A712AEVB
    ../../../Utilities/: gd32a712_evb.c
  group GD32A7xx_Peripherals
    ../../../../GD32A7xx_Firmware_Library/GD32A7xx_standard_peripheral/Source/: gd32a7xx_adc.c gd32a7xx_bkp.c gd32a7xx_busim.c gd32a7xx_can.c gd32a7xx_cltcfg.c gd32a7xx_cmp.c gd32a7xx_crc.c gd32a7xx_dac.c gd32a7xx_dbg.c gd32a7xx_dma.c gd32a7xx_exti.c gd32a7xx_extmpu.c gd32a7xx_fmc.c gd32a7xx_fmu.c gd32a7xx_fwdgt.c gd32a7xx_gdap.c gd32a7xx_gpio.c gd32a7xx_hsmif.c gd32a7xx_i2c.c gd32a7xx_imicu.c gd32a7xx_irm.c gd32a7xx_jdc.c gd32a7xx_linflexd_lin.c gd32a7xx_linflexd_uart.c gd32a7xx_mfcom.c gd32a7xx_misc.c gd32a7xx_mtc.c gd32a7xx_pmu.c gd32a7xx_prpu.c gd32a7xx_qspi.c gd32a7xx_rcu.c gd32a7xx_rtc.c gd32a7xx_spi.c gd32a7xx_sram_tcm.c gd32a7xx_stcm.c gd32a7xx_syscfg.c gd32a7xx_timer.c gd32a7xx_trigsel.c gd32a7xx_wwdgt.c
  group Startup
    ../../../../GD32A7xx_Firmware_Library/CMSIS/GD/GD32A7xx/Source/IAR/: startup_gd32a711x_a712x.s
