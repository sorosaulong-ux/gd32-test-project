# Keil uVision project GD32A712AEVB.uvprojx, settings and files
target GD32A712EVB (6130001::V6.13.1::.\ARMCLANG)
  device: GD32A712AI:CM7_0 GigaDevice
  pack: GigaDevice.GD32A7xx_DFP.0.3.1
  cpu: IRAM(0x24000000,0x28000) IRAM2(0x00000000,0x8000) IROM(0x08000000,0x200000) IROM2(0x08800000,0x20000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: GD32A712AEVB
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32A711X_A712X
  c misc: -Wassign-enum
  c include: ..\;..\..\..\Utilities;..\..\..\..\GD32A7xx_Firmware_Library\GD32A7xx_standard_peripheral\Include;..\..\..\..\GD32A7xx_Firmware_Library\CMSIS\GD\GD32A7xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8800000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0x28000
  memory RVCT10: RAM 0x0 size 0x8000
  group Application
    ../: main.c gd32a7xx_it.c systick.c
  group CMSIS
    ../../../../GD32A7xx_Firmware_Library/CMSIS/GD/GD32A7xx/Source/: system_gd32a71xx_a74xx.c gd32a7xx_err_report.c
  group GD32A7xx_Peripherals
    ../../../../GD32A7xx_Firmware_Library/GD32A7xx_standard_peripheral/Source/: gd32a7xx_adc.c gd32a7xx_bkp.c gd32a7xx_busim.c gd32a7xx_can.c gd32a7xx_cltcfg.c gd32a7xx_cmp.c gd32a7xx_crc.c gd32a7xx_dac.c gd32a7xx_dbg.c gd32a7xx_dma.c gd32a7xx_exti.c gd32a7xx_extmpu.c gd32a7xx_fmc.c gd32a7xx_fmu.c gd32a7xx_fwdgt.c gd32a7xx_gdap.c gd32a7xx_gpio.c gd32a7xx_hsmif.c gd32a7xx_i2c.c gd32a7xx_imicu.c gd32a7xx_irm.c gd32a7xx_jdc.c gd32a7xx_mcmu.c gd32a7xx_misc.c gd32a7xx_mtc.c gd32a7xx_pmu.c gd32a7xx_prpu.c gd32a7xx_qspi.c gd32a7xx_rcu.c gd32a7xx_rtc.c gd32a7xx_spi.c gd32a7xx_sram_tcm.c gd32a7xx_stcm.c gd32a7xx_syscfg.c gd32a7xx_timer.c gd32a7xx_trigsel.c gd32a7xx_wwdgt.c gd32a7xx_linflexd_lin.c gd32a7xx_linflexd_uart.c
  group GD32A712AEVB
    ../../../Utilities/: gd32a712_evb.c
  group Startup
    ../../../../GD32A7xx_Firmware_Library/CMSIS/GD/GD32A7xx/Source/ARM/: startup_gd32a711x_a712x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
