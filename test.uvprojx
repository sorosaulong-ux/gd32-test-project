# Keil uVision project test.uvprojx, settings and files
target GD32A712EVB (6180000::V6.18::ARMCLANG)
  device: GD32A712AI:CM7_0 GigaDevice
  pack: GigaDevice.GD32A7xx_DFP.0.4.1
  cpu: IRAM(0x24000000,0x28000) IRAM2(0x00000000,0x8000) IROM(0x08000000,0x200000) IROM2(0x08800000,0x20000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: GD32A712AEVB +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32A711X_A712X,USE_STDPERIPH_DRIVER
  c misc: -Wassign-enum
  c include: ..\;.\Hardware;.\Library;.\Start;.\System;.\User;.\DW3000;.\NET\MQTT;.\NET\onenet\inc;.\NET\CJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8800000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0x28000
  memory RVCT10: RAM 0x0 size 0x8000
  group Start
    ./Start/: gd32a7xx_err_report.c startup_gd32a711x_a712x.s system_gd32a71xx_a74xx.c
  group System
    ./System/: systick.c systick.h
  group User
    ./User/: gd32a7xx_it.c gd32a7xx_it.h gd32a7xx_libopt.h main.c
  group Hardware
    ./Hardware/: gd32a712_evb.c gd32a712_evb.h oled.c oled.h OLED_Font.h uart.h uart.c can.c can.h can_diag.c can_diag.h uwb.c uwb.h uwb_port.c uwb_port.h buzzer.c key.c esp8266.c usart_esp.c
  group NET
    ./NET/CJSON/: cJSON.c
    ./NET/MQTT/: MqttKit.c
    ./NET/onenet/src/: onenet.c base64.c hmac_sha1.c
  group Library
    ./Library/: gd32a7xx_adc.c gd32a7xx_adc.h gd32a7xx_bkp.c gd32a7xx_bkp.h gd32a7xx_busim.c gd32a7xx_busim.h gd32a7xx_can.c gd32a7xx_can.h gd32a7xx_cltcfg.c gd32a7xx_cltcfg.h gd32a7xx_cmp.c gd32a7xx_cmp.h gd32a7xx_crc.c gd32a7xx_crc.h gd32a7xx_dac.c gd32a7xx_dac.h gd32a7xx_dbg.c gd32a7xx_dbg.h gd32a7xx_dma.c gd32a7xx_dma.h gd32a7xx_enet.c gd32a7xx_enet.h gd32a7xx_exti.c gd32a7xx_exti.h gd32a7xx_extmpu.c gd32a7xx_extmpu.h gd32a7xx_fmc.c gd32a7xx_fmc.h gd32a7xx_fmu.c gd32a7xx_fmu.h gd32a7xx_fwdgt.c gd32a7xx_fwdgt.h gd32a7xx_gdap.c gd32a7xx_gdap.h gd32a7xx_gpio.c gd32a7xx_gpio.h gd32a7xx_hsmif.c gd32a7xx_hsmif.h gd32a7xx_hwsem.c gd32a7xx_hwsem.h gd32a7xx_i2c.c gd32a7xx_i2c.h gd32a7xx_imicu.c gd32a7xx_imicu.h gd32a7xx_ioc.h gd32a7xx_irm.c gd32a7xx_irm.h gd32a7xx_jdc.c gd32a7xx_jdc.h gd32a7xx_linflexd_lin.c gd32a7xx_linflexd_lin.h gd32a7xx_linflexd_uart.c gd32a7xx_linflexd_uart.h gd32a7xx_mcmu.c gd32a7xx_mcmu.h gd32a7xx_mfcom.c gd32a7xx_mfcom.h gd32a7xx_misc.c gd32a7xx_misc.h gd32a7xx_mtc.c gd32a7xx_mtc.h gd32a7xx_pmu.c gd32a7xx_pmu.h gd32a7xx_prpu.c gd32a7xx_prpu.h gd32a7xx_qspi.c gd32a7xx_qspi.h gd32a7xx_rcu.c gd32a7xx_rcu.h gd32a7xx_rtc.c gd32a7xx_rtc.h gd32a7xx_sent.h gd32a7xx_spi.c gd32a7xx_spi.h gd32a7xx_sram_tcm.c gd32a7xx_sram_tcm.h gd32a7xx_stcm.c gd32a7xx_stcm.h gd32a7xx_syscfg.c gd32a7xx_syscfg.h gd32a7xx_timer.c gd32a7xx_timer.h gd32a7xx_trigsel.c gd32a7xx_trigsel.h gd32a7xx_wwdgt.c gd32a7xx_wwdgt.h gd32a7xx.h system_gd32a7xx.h gd32a7xx_err_report.h
  group DW3000
    ./DW3000/: deca_device.c
software components: CMSIS:CORE 5.6.0
